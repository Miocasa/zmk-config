## config/shields/nicepad/Kconfig.defconfig
```kconfig
if SHIELD_NICEPAD

config ZMK_KEYBOARD_NAME
    default "nicepad"

endif # SHIELD_NICEPAD
```
